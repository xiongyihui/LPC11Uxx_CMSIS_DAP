# Keil uVision project USBHid.uvproj, settings and files
target USBHID_Release (ARM-ADS)
  device: LPC11U24/401 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: USBHid +hex
  AfterMake: fromelf --bin -o firmware.bin obj\usbhid.axf
  AfterMake: .\tool\fix_checksum.exe firmware.bin
  c flags: Optim=1
  c define: __DEBUG_FLASH
  c include: .;..\Common\inc;..\USBDriver;cmsis_dap
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group App
    ./: main.c
  group Startup
    ../Common/src/: core_cm0.c system_LPC11Uxx.c startup_LPC11Uxx.s
  group CMSIS DAP
    ./cmsis_dap/: DAP.c JTAG_DP.c SW_DP.c
  group USB
    ./: usbdesc.c usbuser.c hiduser.c io_event.c
    ../USBDriver/: usbhw.c usbcore.c
